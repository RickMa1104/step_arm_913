# Keil uVision project XY-Motor.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: XY-Motor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: ..\User;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Drivers\STM32F0xx_StdPeriph_Driver\inc;..\Drivers\BSP\SysTick;..\Drivers\BSP\DMX512;..\Drivers\BSP\MOTOR;..\Drivers\BSP\DISPKEY;..\Drivers\BSP\STMFLASH;..\Application\Menu;..\Application\Fun;..\Middleware\FreeRTOS\Source\include;..\Middleware\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\Drivers\BSP\LASER;..\Drivers\BSP\SOUND;..\Drivers\BSP\LED;..\Drivers\BSP\ADC;..\Application\Command;.\code;..\Project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000100 size 0x1e00
  group User
    ../User/: main.c stm32f0xx_it.c
    ./code/: laser.c step.c customTimer.c draw.c coordinate.c
  group BSP
    ../Drivers/BSP/MOTOR/: bsp_motor.c
    ../Drivers/BSP/SysTick/: bsp_systick.c
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group StdPeriph_Driver
    ../Drivers/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group FreeRTOS-Port
    ../Middleware/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group FreeRTOS-Source
    ../Middleware/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS-Mem
    ../Middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
target Target Bin (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: XY-Motor-Bin
  AfterMake: D:\Program Files (x86)\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o  ..\Project\Objects\XY-Motor-Bin.bin ..\\Project\Objects\XY-Motor-Bin.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: ..\User;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Drivers\STM32F0xx_StdPeriph_Driver\inc;..\Drivers\BSP\SysTick;..\Drivers\BSP\DMX512;..\Drivers\BSP\MOTOR;..\Drivers\BSP\DISPKEY;..\Drivers\BSP\STMFLASH;..\Application\Menu;..\Application\Fun;..\Middleware\FreeRTOS\Source\include;..\Middleware\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\Drivers\BSP\LASER;..\Drivers\BSP\SOUND;..\Drivers\BSP\LED;..\Drivers\BSP\ADC;..\Application\Command
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000100 size 0x1e00
